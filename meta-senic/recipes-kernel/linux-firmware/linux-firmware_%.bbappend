PACKAGES =+ "${PN}-mediatek"

FILES_${PN}-mediatek = "/lib/firmware/mt7601u.bin"
